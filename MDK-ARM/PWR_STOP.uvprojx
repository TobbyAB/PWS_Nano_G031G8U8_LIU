# Keil uVision project PWR_STOP.uvprojx, settings and files
target PWR_STOP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G031G8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: PWR_STOP_0614 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G031xx
  c include: ../Core/Inc;     ../Drivers/STM32G0xx_HAL_Driver/Inc;     ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;     ../Drivers/CMSIS/Device/ST/STM32G0xx/Include;     ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../: 修改记录.txt
    ../Core/Src/: main.c gpio.c tim.c stm32g0xx_it.c stm32g0xx_hal_msp.c sysdata.c valvecheck.c IOcheck.c relay.c iwdg.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
